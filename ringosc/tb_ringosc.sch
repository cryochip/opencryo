v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/brito/sky130_opensource_skel/opencryo/ringosc/ringosc.sym} 60 -100 0 0 {name=X1}
